# Keil uVision project e230c8t6v2.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: GD32E230C8 GigaDevice
  pack: GigaDevice.GD32E23x_DFP.1.0.2
  cpu: IRAM(0x20000000,0x0002000) IROM(0x08000000,0x0010000) CPUTYPE("Cortex-M23") CLOCK(12000000) ELITTLE
  output: e230c8t6v2 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=1
  c define: GD32E230
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Source Group 1
    ./: main.c usart_print.h adc_joytick.h gpio_init.h gpio_init.c sys_tick.h sys_tick.c
software components: CMSIS:CORE 5.6.0, Device:EVAL:GD32E23x 1.0.0, Device:GD32E23x_StdPeripherals:ADC 1.0.0, Device:GD32E23x_StdPeripherals:DMA 1.0.0, Device:GD32E23x_StdPeripherals:EXTI 1.0.0, Device:GD32E23x_StdPeripherals:FMC 1.0.0, Device:GD32E23x_StdPeripherals:GPIO 1.0.0, Device:GD32E23x_StdPeripherals:MISC 1.0.0, Device:GD32E23x_StdPeripherals:RCU 1.0.0, Device:GD32E23x_StdPeripherals:SYSCFG 1.0.0, Device:GD32E23x_StdPeripherals:USART 1.0.0, Device:GD32E23x_libopt 1.0.0, Device:Startup 1.0.0
