# Keil uVision project f103c8t6.uvprojx, settings and files
target Target (6190000::V6.19::ARMCLANG)
  device: GD32F103C8 GigaDevice
  pack: GigaDevice.GD32F10x_DFP.2.0.3
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: f103c8t6
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source
    ./: main.c all.h
software components: CMSIS:CORE 5.6.0, Device:GD32F10x_StdPeripherals:GPIO 2.0.2, Device:GD32F10x_StdPeripherals:MISC 2.0.2, Device:GD32F10x_StdPeripherals:PMU 2.0.2, Device:GD32F10x_StdPeripherals:RCU 2.0.2, Device:GD32F10x_libopt 2.0.2, Device:Startup 2.0.2
