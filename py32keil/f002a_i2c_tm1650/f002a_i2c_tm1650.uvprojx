# Keil uVision project f002a_i2c_tm1650.uvprojx, settings and files
target Target (6190000::V6.19::ARMCLANG)
  device: PY32F002Ax5 Puya
  pack: Puya.PY32F0xx_DFP.1.2.1
  cpu: IRAM(0x20000000,0x00000C00) IROM(0x08000000,0x00005000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: f002a_i2c_tm1650
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=1 wLevel=2
  c define: PY32F002Ax5 USE_HAL_TIM_REGISTER_CALLBACKS USE_HAL_UART_REGISTER_CALLBACKS USE_HAL_I2C_REGISTER_CALLBACKS
  c include: ..\f002a_i2c_tm1650;.\Drivers\PY32F0xx_HAL_Driver\Inc;.\Drivers\BSP\PY32F002xx_Start_Kit
  memory RVCT4: ROM 0x8000000 size 0x5000
  memory RVCT9: RAM 0x20000000 size 0xc00
  group Source
    ./: main.c py32f0xx_hal_msp.c py32f0xx_it.c
  group Drivers\PY32F0xx_HAL_Driver
    ./Drivers/PY32F0xx_HAL_Driver/Src/: py32f0xx_hal.c py32f0xx_hal_gpio.c py32f0xx_hal_i2c.c py32f0xx_hal_pwr.c py32f0xx_hal_rcc.c py32f0xx_hal_uart.c py32f0xx_hal_cortex.c
  group Drivers\BSP\PY32F002xx_Start_Kit
    ./Drivers/BSP/PY32F002xx_Start_Kit/: py32f002xx_Start_Kit.c
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.0
