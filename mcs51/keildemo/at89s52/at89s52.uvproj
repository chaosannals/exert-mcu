# Keil uVision project at89s52.uvproj, settings and files
target Target (MCS-51)
  device: AT89S52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODP2
  output: at89s52 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group
    ./: STARTUP.A51 main.c
